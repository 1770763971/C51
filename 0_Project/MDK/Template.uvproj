# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Libraries\Common;..\..\Libraries\Libraries;..\CODE;..\USER
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/STARTUP/: STARTUP.A51
  group Common
    ../../Libraries/Common/: common.c delay.c key.c picture.c show.c Sys_Init.c variable.c
  group Libraries
    ../../Libraries/Libraries/: ds1302.c i2c.c Infrared.c lcd1602.c lcd12864.c nrf2401.c pwm.c XPT2046.c Lcd12864NoFont.c DS18b20.c
  group User
    ../USER/: isr.c Main.c
